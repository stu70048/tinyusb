# Keil uVision project cdc_msc.uvprojx, settings and files
target FullSpeed (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.1
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: cdc_msc
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CFG_TUSB_DEBUG=1,CFG_TUSB_MCU=OPT_MCU_M55x
  c include: ..\..\..\..\hw\mcu\m55m1\Library\CMSIS\Core\Include;..\..\..\..\hw\mcu\m55m1\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\hw\mcu\m55m1\Library\StdDriver\inc;..\..\..\..\src;..\src;..\..\..\..\hw
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\..\hw\mcu\m55m1\Library\Device\Nuvoton\M55M1\Source\ARM\M55M1.scatter
  group CMSIS
    ../../../../hw/mcu/m55m1/Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../../hw/mcu/m55m1/Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c
  group User
    ../src/: main.c msc_disk.c usb_descriptors.c tusb_config.h
    ../../../../src/: tusb_option.h
  group TinyUSBlib
    ../../../../src/class/msc/: msc_device.c
    ../../../../src/common/: tusb_fifo.c
    ../../../../src/device/: usbd_control.c usbd.c
    ../../../../src/portable/nuvoton/m55m1/: dcd_HSUSBD.c dcd_USBD.c
    ../../../../src/: tusb.c
    ../../../../src/class/cdc/: cdc_device.c
  group hw
    ../../../../hw/bsp/numaker_m55m1/: numaker_m55m1_hsusbd.c numaker_m55m1_usbd.c
target HighSpeed (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.1
  cpu: as above
  output: cdc_msc
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CFG_TUSB_DEBUG=1,CFG_TUSB_MCU=OPT_MCU_M55x,CFG_TUSB_MEM_DCACHE_LINE_SIZE_DEFAULT=32
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: as above
